# Keil uVision project 摇摇棒.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC12C2052AD STC
  cpu: IRAM(0-0xFF) IROM(0-0x7FF) CLOCK(45000000)
  output: prog +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c STC12x20xx.h
    ../../mylibs/: asciiCode.h
