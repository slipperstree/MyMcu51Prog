# Keil uVision project 16x64LED.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: prog +hex
  c flags: Optimize=8
  group Source Group 1
    ./: STC12C5A60S2.h 16x64LED_ForNewPCB_16x64_ScrollText_V2.c
