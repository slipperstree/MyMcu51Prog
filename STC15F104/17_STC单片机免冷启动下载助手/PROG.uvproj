# Keil uVision project PROG.uvproj, settings and files
target Target 1 (MCS-51)
  device: 8052AH Intel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(12000000)
  output: prog +hex
  c flags: Optimize=7 SizeSpeed=1
  group Source Group 1
    ./: main.c
  group function
    ./function/: common.c uart.c
