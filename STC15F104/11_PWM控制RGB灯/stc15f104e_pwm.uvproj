# Keil uVision project stc15f104e_pwm.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F104E STC
  cpu: IRAM(0-0x7F) IROM(0-0xFF8) CLOCK(35000000)
  output: stc15f104e_pwm +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STC15104E.h STC15104E.c
