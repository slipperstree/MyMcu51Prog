# Keil uVision project PROG.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15W408AS STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FF8) CLOCK(35000000) MODP2
  output: prog +hex
  c flags: Optimize=9 SizeSpeed=1
  group Source Group 1
    ./: main.c
  group function
    ./function/: uart.c common.c display.c ds1302.c key.c sensorAdc.c
